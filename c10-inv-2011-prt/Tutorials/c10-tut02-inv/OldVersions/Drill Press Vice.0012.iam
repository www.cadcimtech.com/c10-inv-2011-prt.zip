# Autodesk Inventor assembly: Drill Press Vice
## iProperties
Created: 2009-05
Part Number: Drill Press Vice
Document SubType Name: Assembly
Designer: Sham
Author: Sham
