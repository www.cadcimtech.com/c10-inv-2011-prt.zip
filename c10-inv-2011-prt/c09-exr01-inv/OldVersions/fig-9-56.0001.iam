# Autodesk Inventor assembly: fig-9-56
## iProperties
Created: 2009-05
Part Number: fig-9-56
Document SubType Name: Assembly
Designer: Sham
Author: Sham
